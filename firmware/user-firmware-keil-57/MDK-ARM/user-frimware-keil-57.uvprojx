# Keil uVision project user-frimware-keil-57.uvprojx, settings and files
target user-frimware-keil-57 (6190000::V6.19::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: user-frimware-keil-57 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=7 wLevel=3
  c define: USE_HAL_DRIVER,STM32F1,STM32F1xx,STM32F103xB
  c include: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\Ctrl\Driver; ..\Ctrl\Motor; ..\Ctrl\Sensor\Encoder; ..\Ctrl\Signal; ..\Port; ..\Port\Platform; ..\Port\Platform\Memory; ..\Port\Platform\Utils; ..\UserApp; ..\UserApp\protocols; ..\Ctrl
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Ctrl/Driver
    ../Ctrl/Driver/: tb67h450_base.cpp
  group Ctrl/Motor
    ../Ctrl/Motor/: motion_planner.cpp motor.cpp
  group Ctrl/Encoder
    ../Ctrl/Sensor/Encoder/: encoder_calibrator_base.cpp mt6816_base.cpp
  group Ctrl/Signal
    ../Ctrl/Signal/: button_base.cpp led_base.cpp
  group Port
    ../Port/: button_stm32.cpp encoder_calibrator_stm32.cpp led_stm32.cpp mt6816_stm32.cpp tb67h450_stm32.cpp
  group Port/Platform
    ../Port/Platform/: retarget.c
  group Port/Memory
    ../Port/Platform/Memory/: stockpile_f103cb.c emulated_eeprom.cpp
  group Port/Utils
    ../Port/Platform/Utils/: st_hardware.c
  group UserApp
    ../UserApp/: main.cpp
  group UserApp/protocols
    ../UserApp/protocols/: interface_can.cpp interface_uart.cpp
software components: CMSIS:CORE 5.6.0
